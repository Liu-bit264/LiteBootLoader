# Keil uVision project app.uvprojx, settings and files
target app (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08004000,0xB800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: app
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c misc: -Ospace
  c include: core;port;port\stm32f1\f103c8t6;bsp\oled_ssd1306;third_party\CMSIS;app\examples\f103c8t6_app
  library: MicroLIB
  memory RVCT4: ROM 0x08004000 size 0xB800
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: linker\app.sct
  group Startup
    port/stm32f1/f103c8t6/: startup_stm32f10x_md.s
  group App
    app/examples/f103c8t6_app/: main.c app_request.c
  group Core
    core/: bl_metadata.c bl_crc.c
  group CMSIS
    third_party/CMSIS/: core_cm3.c
  group Port
    port/stm32f1/f103c8t6/: clock.c systick.c uart.c gpio.c i2c.c wdg.c flash.c
  group BSP
    bsp/oled_ssd1306/: ssd1306.c ssd1306_font.c
