# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(25000000) ELITTLE
  output: bootloader
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=1 wLevel=2
  c define: STM32F411xE
  c misc: -Ospace
  c include: ..\..\core;..\..\port;..\..\port\stm32f4\f411ceu6;..\..\third_party\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x08000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\linker\f411ceu6\bootloader.sct
  group Startup
    ../../port/stm32f4/f411ceu6/: startup_stm32f411xe.s bl_jump.s
  group Core
    ../../core/: bl_core.c bl_protocol.c bl_transport.c bl_storage.c bl_metadata.c bl_boot.c bl_crc.c bl_service_stub.c
  group Services
    ../../services/display_led/: bl_display_led.c
    ../../services/debug_uart/: bl_debug_uart.c
  group Port
    ../../port/stm32f4/f411ceu6/: main.c clock.c systick.c uart.c gpio.c wdg.c flash.c
    ../../port/: wifi_stub.c
