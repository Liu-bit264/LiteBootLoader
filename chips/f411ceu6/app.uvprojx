# Keil uVision project app.uvprojx, settings and files
target app (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x08010000,0x70000) CPUTYPE("Cortex-M4") CLOCK(25000000) ELITTLE
  output: app
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=1 wLevel=2
  c define: STM32F411xE
  c misc: -Ospace
  c include: ..\..\core;..\..\port;..\..\port\stm32f4\f411ceu6;..\..\third_party\CMSIS;..\..\app\examples\f411ceu6_app
  library: MicroLIB
  memory RVCT4: ROM 0x08010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\linker\f411ceu6\app.sct
  group Startup
    ../../port/stm32f4/f411ceu6/: startup_stm32f411xe.s
  group App
    ../../app/examples/f411ceu6_app/: main.c app_request.c
  group Core
    ../../core/: bl_metadata.c bl_crc.c
  group Port
    ../../port/stm32f4/f411ceu6/: clock.c systick.c uart.c gpio.c wdg.c flash.c
