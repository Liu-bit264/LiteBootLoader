# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c misc: -Ospace
  c include: core;port;port\stm32f1\f103c8t6;bsp\oled_ssd1306;third_party\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x08000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: linker\bootloader.sct
  group Startup
    port/stm32f1/f103c8t6/: startup_stm32f10x_md.s bl_jump.s
  group Core
    core/: bl_core.c bl_protocol.c bl_transport.c bl_storage.c bl_metadata.c bl_boot.c bl_crc.c
  group Services
    services/display_oled/: bl_display_oled.c
    services/debug_uart/: bl_debug_uart.c
  group CMSIS
    third_party/CMSIS/: core_cm3.c
  group Port
    port/stm32f1/f103c8t6/: main.c clock.c systick.c uart.c gpio.c wdg.c flash.c i2c.c
  group BSP
    bsp/oled_ssd1306/: ssd1306.c ssd1306_font.c
